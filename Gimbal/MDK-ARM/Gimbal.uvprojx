# Keil uVision project Gimbal.uvprojx, settings and files
target Gimbal (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Gimbal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../bsp;../calculate;../task;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../SEGGER_RTT;../../phoenix_embedded_base_code/Algorithm/Pid;../../phoenix_embedded_base_code/Bsp/Can;../../phoenix_embedded_base_code/Bsp/Fdcan;../../phoenix_embedded_base_code/Bsp/Log;../../phoenix_embedded_base_code/Module/Motor/Dji;../../phoenix_embedded_base_code/Module/Motor/Dm;../../phoenix_embedded_base_code/Module/Minipc;../../phoenix_embedded_base_code/Module/Com_System;../IMU_Libs;../IMU_Libs/BMI088;../IMU_Libs/DWT;../IMU_Libs/GPIO;../IMU_Libs/I2c;../IMU_Libs/Ist8310;../IMU_Libs/Kalman;../IMU_Libs/SPI;../IMU_Libs/Uart;../Middlewares/ST/ARM/DSP/Inc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group SEGGER_RTT
    ../../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group rc
    ../bsp/: bsp_rc.c bsp_rc.h remote_control.c remote_control.h struct_typedef.h
  group bsp
    ../../phoenix_embedded_base_code/Bsp/Can/: bsp_can.c bsp_can.h robot_config.h
    ../../phoenix_embedded_base_code/Bsp/Fdcan/: bsp_fdcan.c bsp_fdcan.h
    ../../phoenix_embedded_base_code/Bsp/Log/: bsp_log.c bsp_log.h
  group calculate
    ../calculate/: GimbalFun.c GimbalFun.h ShootFun.c ShootFun.h
  group Pid
    ../../phoenix_embedded_base_code/Algorithm/Pid/: alg_pid.c alg_pid.h
  group Dji
    ../../phoenix_embedded_base_code/Module/Motor/Dji/: dev_motor_dji.c dev_motor_dji.h
  group Dm
    ../../phoenix_embedded_base_code/Module/Motor/Dm/: dev_motor_dm.c dev_motor_dm.h
  group task
    ../task/: GimbaTask.c GimbalTask.h ShootTask.c ShootTask.h CanTask.c CanTask.h MinipcTask.c MinipcTask.h
  group Minipc
    ../../phoenix_embedded_base_code/Module/Minipc/: dev_minipc.c dev_minipc.h
  group Com_system
    ../../phoenix_embedded_base_code/Module/Com_System/: Com_System.c Com_System.h Queue.c Queue.h
  group IMU_Libs
    ../IMU_Libs/: app_ins_task.c alg_fliter.c alg_fliter.h bsp_pwm.c bsp_pwm.h MahonyAHRS.c MahonyAHRS.h
    ../IMU_Libs/BMI088/: bmi088_error_check_example.c dev_bmi088.c
    ../IMU_Libs/DWT/: bsp_dwt.c
    ../IMU_Libs/GPIO/: bsp_gpio.c
    ../IMU_Libs/I2c/: bsp_iic.c
    ../IMU_Libs/Ist8310/: dev_ist_8310.c
    ../IMU_Libs/Kalman/: alg_kalman.c alg_quaternionEKF.c Kalman.c kalman_filter.c
    ../IMU_Libs/SPI/: bsp_spi.c bsp_spi.h
    ../IMU_Libs/Uart/: bsp_uart.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0
