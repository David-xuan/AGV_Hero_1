# Keil uVision project Chassis.uvprojx, settings and files
target Chassis (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Chassis +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../task;../motor;../calculate;../bsp;../../phoenix_embedded_base_code/Bsp/Can;../../phoenix_embedded_base_code/Bsp/Fdcan;../../phoenix_embedded_base_code/Bsp/Log;../../SEGGER_RTT;../../phoenix_embedded_base_code/Algorithm/Pid;../../phoenix_embedded_base_code/Module/Motor/Dji;../../phoenix_embedded_base_code/Algorithm/Chassis_calc;../../phoenix_embedded_base_code/Module/Motor/Lk;../../phoenix_embedded_base_code/Module/Referee;../../phoenix_embedded_base_code/Bsp/Uart;../../phoenix_embedded_base_code/Module/Daemon;../../phoenix_embedded_base_code/Algorithm/Crc
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c crc.c dma.c i2c.c spi.c tim.c usart.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group SEGGER_RTT
    ../../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group Bsp
    ../../phoenix_embedded_base_code/Bsp/Can/: bsp_can.c bsp_can.h robot_config.h
    ../../phoenix_embedded_base_code/Bsp/Fdcan/: bsp_fdcan.c bsp_fdcan.h
    ../../phoenix_embedded_base_code/Bsp/Log/: bsp_log.c bsp_log.h
  group rc
    ../bsp/: bsp_rc.c bsp_rc.h remote_control.c remote_control.h struct_typedef.h
  group calculate
    ../../phoenix_embedded_base_code/Algorithm/Chassis_calc/: alg_chassis_calc.c alg_chassis_calc.h
    ../calculate/: ChassisFun.c ChassisFun.h GImbalFun.c GImbalFun.h
  group Dji
    ../../phoenix_embedded_base_code/Module/Motor/Dji/: dev_motor_dji.c dev_motor_dji.h
  group Lk
    ../../phoenix_embedded_base_code/Module/Motor/Lk/: dev_motor_lk.c dev_motor_lk.h
  group Pid
    ../../phoenix_embedded_base_code/Algorithm/Pid/: alg_pid.c alg_pid.h
  group task
    ../task/: ChassisTask.c ChassisTask.h GimbalTask.c GimbalTask.h CanTask.c CanTask.h RefereeTask.c RefereeTask.h
  group uart
    ../../phoenix_embedded_base_code/Bsp/Uart/: bsp_uart.c bsp_uart.h
  group Referee
    ../../phoenix_embedded_base_code/Module/Referee/: dev_referee.c dev_referee.h dev_referee_protocol.h dev_referee_ui.c dev_referee_ui.h
  group Daemon
    ../../phoenix_embedded_base_code/Module/Daemon/: dev_daemon.c dev_daemon.h
  group Crc
    ../../phoenix_embedded_base_code/Algorithm/Crc/: alg_crc.c alg_crc.h
software components: CMSIS:CORE 4.3.0
